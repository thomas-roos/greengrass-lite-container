FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://subuid \
    file://subgid \
"
