FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://containers.conf \
    file://storage.conf \
"
